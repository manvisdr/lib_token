## esp32-s2_espidf/src/components/uvc_stream/Kconfig
```kconfig
menu "UVC Stream"

    config TRIGGER_PIN
        bool "Enable Trigger Pin For Debug"
        default false

endmenu
```
